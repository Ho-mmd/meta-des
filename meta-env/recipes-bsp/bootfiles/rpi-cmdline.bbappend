CMDLINE:append = " fbcon=map:2"
