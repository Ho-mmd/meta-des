FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://seeed-can-fd-hat-v2.dtbo \
"
