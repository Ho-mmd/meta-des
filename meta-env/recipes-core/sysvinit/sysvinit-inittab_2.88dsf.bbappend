FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI = "file://inittab \
           file://start_getty"
