FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SPLASH_IMAGES:forcevariable = "file://boot-logo.png;outsuffix=default"
